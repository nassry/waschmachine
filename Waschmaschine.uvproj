# Keil uVision project Waschmaschine.uvproj, settings and files
target Target 1 (MCS-51)
  device: XC886-6FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF5FF) IROM(0-0x4FFF) IROM2(0xA000-0xAFFF) CLOCK(24000000) MODP2
  output: Waschmaschine
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adclib.c DIP204_XC886.c main.c
